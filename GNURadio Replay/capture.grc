options:
  parameters:
    author: Ayyappan Rajesh
    description: Capture key fob transmission
    generate_options: qt_gui
    id: captureFile
    output_language: python
    title: Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Ayyappan\Desktop\GNURadio Replay\RollWindows
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '16'
    freq0: '434215000'
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"GUI"'
    plotfreq: 'False'
    rate: '5'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
